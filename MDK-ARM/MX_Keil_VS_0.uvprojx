# Keil uVision project MX_Keil_VS_0.uvprojx, settings and files
target MX_Keil_VS_0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: MX_Keil_VS_0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no-multibyte-chars --gnu
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Mid/Include;../Mid/ThirdParty/Include;../BSP/Include;../BSP/ThirdParty/Include;../App/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group MySource
    ../App/Source/AdjustableFans/: app_adjustablefans.c
    ../App/Source/: app_crackpassword.c
    ../BSP/Source/ADC_DAC/: bsp_adc.c
    ../BSP/Source/Bluetooth/: bsp_bt.c
    ../BSP/Source/Encoder/: bsp_encoder.c
    ../BSP/Source/IIC/: bsp_iic.c
    ../BSP/Source/Key/: bsp_key.c
    ../BSP/Source/LowPower/: bsp_lowpower.c
    ../BSP/Source/Moter/: bsp_moter.c
    ../BSP/Source/Seg/: bsp_seg.c
    ../BSP/Source/Servo/: bsp_servo.c
    ../BSP/Source/Serial/: bsp_serial.c
    ../BSP/Source/SPI/: bsp_spi.c
    ../BSP/Source/Tool/: bsp_tool.c
    ../Mid/Source/ADC_DAC/: mid_adc.c
    ../Mid/Source/Common/: mid_parce.c
    ../Mid/Source/Encoder/: mid_encoder.c
    ../Mid/Source/Key/: mid_key.c
    ../Mid/Source/Moter/: mid_tb6612.c
    ../Mid/Source/Seg/: mid_seg.c
    ../Mid/Source/Serial/: mid_ci_03t.c mid_serial.c mid_dfplayermini.c mid_snr9816.c
    ../Mid/Source/Servo/: mid_servo.c
    ../Mid/Source/SPI/: mid_nrf24l01.c
    ../BSP/ThirdParty/Source/OLED/: bsp_oled.c
    ../Mid/ThirdParty/Source/Bluetooth/: mid_bt.c
    ../Mid/ThirdParty/Source/MPU6050/: I2C.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
    ../Mid/ThirdParty/Source/OLED/: mid_oled.c mid_oledfont.c
software components: CMSIS:CORE 4.3.0
